#include<ESP8266WiFi.h>
#include<ESP8266HTTPClient.h>
#include<WiFiClientSecureAxTLS.h> 
#include<ArduinoJson.h>
#include<TridentTD_LineNotify.h>
#include<SoftwareSerial.h>

#define SSID "Chakthip"
#define PASSWORD "0816879589"
#define LINE_TOKEN "isOT5gbxeiAnHPgqgnDFtfkCvxo7wk8mjJ8uHSJTwEk"
int sw = D1;
int led = D0;
int val;
float tempc;
int button;
String data,dataimg;
String message = "กบ ปลื้ม บริล มุก";
SoftwareSerial NodeSerial(D5,D6); //RX,TX
char *menu[27] = {
  "name1","name2","name3","name4","name5","name6","name7","name8","name9","name10","name11","name12",
  "name13","name14","name15","name16","name17","name18","name19","name20",
  "name21","name22","name23","name24","name25","name26","name27"
  };
char *menuimg[27] = {
  "img1","img2","img3","img4","img5","img6","img7","img8","img9","img10","img11","img12",
  "img13","img14","img15","img16","img17","img18","img19","img20","img21","img22","img23","img24",
  "img25","img26","img27",
};
void setup() {
  delay(50);
  Serial.begin(115200);
  NodeSerial.begin(4800);
  WiFi.mode(WIFI_STA);
  WiFi.begin(SSID,PASSWORD);
  Serial.println("Connecting");
  while(WiFi.status() != WL_CONNECTED){
    Serial.print(".");
    delay(400);
    }
  Serial.println("");
  Serial.println("WiFi Connected");
  Serial.println(LINE.getVersion());
  pinMode(sw,OUTPUT);
  pinMode(led,OUTPUT);
  pinMode(D5,INPUT);
  pinMode(D6,OUTPUT);
  
}

void loop() {
while(1){
    if(NodeSerial.available()>0){
        Serial.print("รับ");
        val = NodeSerial.parseFloat();
        if(NodeSerial.read() == '\n'){
          Serial.println(val);
        }
        break;
    }
}
button = digitalRead(D1);
Serial.println(button);
if(button == HIGH){
  digitalWrite(led,HIGH);
  delay(1000);
  digitalWrite(led,LOW);

  for(int i=1;i<=27;i++){
    if(i == val){
      data = client_get(menu[i-1]);
      dataimg = client_getimg(menuimg[i-1]);
      break;
    }
  }
  
  Serial.println(data);
  Serial.println(dataimg);
  Line_notify(data,dataimg);
  delay(6000);
  }
delay(1000);
}
String client_get(String qnameitem){
  String payload;
  const char *name_item;
  DynamicJsonDocument doc(6500);
  HTTPClient http;
  http.begin("http://43.228.85.133/menu/?fbclid=IwAR3O4MCu5v-Yj1IX95BVsdRRzdAQ2UQsolKFgvfhxwN5bdA-mnX8CR8scfQ");

  int httpcode = http.GET();

  if(httpcode > 0){
    Serial.println("get data");
    payload = http.getString();
//    Serial.println(payload);
    DeserializationError err = deserializeJson(doc,payload);
     
    name_item = doc[qnameitem];
//    Serial.println(name_item);
    
  }
  http.end();
  return name_item;
}

String client_getimg(String qnameimg){
  String payload;
  const char *name_img;
  DynamicJsonDocument doc(6500);
  HTTPClient http;
  http.begin("http://43.228.85.133/menu/?fbclid=IwAR3O4MCu5v-Yj1IX95BVsdRRzdAQ2UQsolKFgvfhxwN5bdA-mnX8CR8scfQ");

  int httpcode = http.GET();

  if(httpcode > 0){
    Serial.println("get data img");
    payload = http.getString();
    DeserializationError err = deserializeJson(doc,payload);

    name_img = doc[qnameimg];
  }
  http.end();
  return name_img;
}

void Line_notify(String message,String img){
  // put your main code here, to run repeatedly:
  LINE.setToken(LINE_TOKEN);
  //การส่งข้อมูลตัวอักษร
  LINE.notify(message);
  delay(1000); // รอ 1 วินาที
//  
//  // เลือก Line Sticker ได้จาก https://drive.google.com/file/d/1fgBuIT4fCRdSNyE6k1qqmmZGTZWJLfwc/view?usp=sharing 
//  // CR: https://devdocs.line.me/files/sticker_list.pdf
//  
//  LINE.notifySticker(1, 100);       // ส่ง Line Sticker ด้วย PackageID 1 , StickerID 100 จะได้สติ๊กเกอร์หัวเราะ
//  LINE.notifySticker("AEI.th ทดสอบ Line", 1, 100); // ส่ง Line Sticker ด้วย PackageID 1 , StickerID 100  พร้อมข้อความ จะได้สติ๊กเกอร์หัวเราะ พร้อมข้อความ
//delay(1000); // รอ 1 วินาที

  // ตัวอย่างส่ง รูปภาพ ด้วย url
  LINE.notifyPicture(img);
 // LINE.notifyPicture("data:image/jpeg;base64,/9j/4AAQSkZJRgABAQAAAQABAAD/2wCEAAkGBxMTEhUTEhMWFhUWFxcaFhgYGR8aGBsYGBcZGhgYGRoYHSggGhomHhgXIjEhJiorLi4uGCA3ODMtNygtLisBCgoKDg0OGxAQGy4mICUtLS8tOC8tNS8tLS0tLS0tLy0tMi0tLS0tLy0tLS0tLy0tLS0tLS8tLS8tLS0tLS0tLf/AABEIAKgBLAMBEQACEQEDEQH/xAAbAAABBQEBAAAAAAAAAAAAAAAAAgMEBQYBB//EAEIQAAIBAgQDBAYIBQQCAQUAAAECAwARBBIhMQUTQQYiUWEUMnGBkdEVQlNikqGxwRYjUuHwBzNDcoLxNCRjorLC/8QAGwEAAQUBAQAAAAAAAAAAAAAAAAIDBAUGAQf/xAA8EQABAgMEBQoFBAIDAQEAAAABAAIDBBEFEiExQVFhkdETFBVxgaGxweHwBiIyU5IWQmLxI1IzgqLScv/aAAwDAQACEQMRAD8AtKt1hUUIT2GwzSGyKT+g9p6VGmpyDLNvRXU8T1BPy8tFjuuwxXy61b4fs/8AaP7l+Z+VZmZ+KDlAZ2u4Dir6BYAziv7BxPBTF4NCPqk+1j+xqrdb0+84Pp1AeYKntseTbm2vWTxQ3BoT9Uj2MfnQ23p9hxfXrA8gh1jybv207TxUTEdnx9R/c3zHyqzlvih1aR2dreB4qDHsAZwn7+I4KnxOFeM2dbeB6H2GtNKzsCabehOr4jrCoZiViy7qRBTwPamalKOihCKEIoQihCKEIoQihCKEIoQihCKEIoQihCKEIoQihCKEIoQihCKEIoQihCKEIoQihCKEIoQihCKEIoQp/C+HGU3OiDc+PkKp7WtZsk263F5yGrafeKs7Os5006pwaM9uwLTwQqgyqLAVgI0eJHiF8Q1JWxhQmQWXGCgCj4ziMcejG5/pGp/t76sJOypqZxhijdZwHqokzaECBg81OoYn0Va/aA/Vj+J/YCr1nw02nzxNw9fJVLreNfkZvPp5oTj56xj3H5ih3wyynyxD2jguNt51fmZuPorDCcUjk0Bs3g2nw6GqWbseZlsbt5usY+o8FaS1pwI+ANDqPuhUqWIMMrAEHoarIcSJAiB8M0I0qdEhsituvFQVmeK8NMRuNUOx6jyPzreWRa7Zxtx+Dx37R5hZC0rNMqbzcWHu2HyKr6u1VIoQlIAb3IUAXJOwFwBtqSSVAABJJAFJe8MFSnoEF8Z9xmaJFymxI6ag3BBFwR5EEH311rg4VCRFYYbyx2YScwrqRUJ4IuW53sxvnUWYMgVOWRmbMC5zAgDJ1vTZc+/QDBSmw4HIF7n/AD6B7xTN6cUWqUVAAJaNb7Z5EQkA2uA7AkXBF/KkOiMaaEqRDlI0Vt5jahDrbe2oBBBBBB1BBBII8xSmuDhUJqJDdDddeKFKhAJN7eqxUFggZgpKqXKsEBNhmsbVx5cG1aMUuXbCdEAiuoNa7Kosp2Y+smZHykW+vGSGFybGynu6gXpMNziPmFE5NQoMNwEJ94eCTFEzGygsfAC5/KlkgZqO1jnmjRUrjoQSCCCNwdCPbXQarhBaaFKhhZzZFLHewBJt7q4SBmlMY55o0E9SRbpXUmmhLmhZDZ1KnwIsfzrgIOSU9jmGjgQdqbrqQlIpJAAJJ0AGpJ8qCaLoBJoFI+jpvspPwn5UjlGawn+ax/8AQ7imJIypswII3BFj8DSgQcQmXNc00cKFIrqSlMhFrgi+ouLXHiPGioXS0jMJNC4ihCclgZbZlZb7XBF/ZeuBwOSW+G9n1AjrTddSEUIRQhORwM2qqxHkCf0rhcBmlthudi0E9iVhMOZHCDr18B1NRp2abKwXRXaO86AnZWXdMRRDbp7hpK2EEQRQqiwG1eZxYz48UxIhqScVvIUJsKGGMFAFUcZ4oQeXGdfrN4eQ8/OtNYlkXwJiOMP2jzPkFRWraRYeRgnHSfIeZ0KirXUos1mn8Lg3kvlGg3J0A99Vs7acGVFYh7Bnq2d+kYVVjKWdGmf+Mdpy8+7QcaLmJwjp6w0PUaim5G1oE3UQziNBwPmKa0qcsyNLYvGGsYjyxTFW4xVarrg/FDcJIbg6Kx3v4H51l7asirTGgDEZjXtHDzV/ZdpkOEKMcNB8jxV5LGGBVhcEa1kYcV0J7YjMCFonw2xGljxUFY/G4YxuUPTY+I6GvTJGbbNwGxW6c9h0j3oWEm5Yy8Ywzoy2jR71pkee1S1H603iMeRMUixEgnGMjjjhzryngZYpXzQKgAiWF5MztdroDn1tVU6pJrmtlCDWtBYAG0qkY/iGJGIkSCZ2zYvCqnOe5RRhnxWKXOFz8q3KBTXYgb13Gt0IaWFgiuAyr2ZrnD8diY3EEk5dvT8KnNzMA0XozYp4wsjMVJ7qHXvZh4a8xBolAtcy+Borkk4ziT8jHvHO6rhYoljMMgC+kCOR5NrhhzJYUI65bdBS4jrznEFR5VnJQocMgVIx8T34LuO4ziIxxCeMxvHhw8ShpRCEljjVZXECRNzH51ypdlvsthakFzjjVSGwobRdDRuTXaHGTPhcU0ckrDCxGFn9IWAiaJAkz5ERpJiZG3YqCTpbek1TgAGSkYvjBhhxskko/wDpW5UQYgBZYcEiqEUm92mkJ03yeVOMdRrlFjwi+LDwwBJO7DvPcm8TjJxHjWeSZRhIikcqSomaeDDRmRpUtnmZpXAJN1A0te9Jq4hPUhh1KCp71YYyRxiTGzsQMGHlQ25azc9IVMS2/l3KT3ANrDzp6DXlBiq+euGVcbowNBvpxVfxGHm2wnLlkWRc+J5IuyxG/Ij1ItzHXOdb5Yh/VSph9TdGhIsqXENnKuzdl1evBK4NiZMQmBSN0RpcMWxEjxCV1MTQ4VQisQoYyiQ63G+htamxEfQNByUp8rBDnRIjQakZ9g8VzD4lsT6Ac8KrjMTE/IVF0hiZsQQHvnYryow9+7d7AC2qHOcRiU7Bgw4bzcZTbrro7FL4ZxsFcFM6xXnWeeUADuwQpNIDv3TrApbxVvOlGK67SqbbJQeULrg0U68TXwUL0+X0dmXkR8jh0WIcCAE+kTriMRlsxsqkIb6E3f30lrnAGhTkaDBe4F7QScPEp7iWMdExTLyYzhkS6MnMMk7wLLkOdrpGzOsSBO8Tc30tS+VeRWqYEjLsdQQ61r2e8gnuMS8hMVIvdMUE7AHXK/LIUX62dlHuqTEceRqdKqpWC0T11uTSe71ULCcMjwmCll9HwCywYJ8ksDtJMZTFywzXiUC5fUhjqQBvUFaKuOnclYnEyx54YIAVwrYfCqH5OWV1jiUq7yzLIlwwC8tdxe7XIChFeBQFMvk4LyXObUn3hqVnwz+bIhV4UQ4p4UikjztIkUjo4Lg8wTkRu+lkUEXBvelmM841TLZCXb8lyuGZVbw/FTNHERMkjYrGYtg0kYcRwQCVZCihhYkRQ2FwASOhNIY5wNGnNPR4cItrEbUNHvwTz4t8uYGFrYpcKsXLUNKUmWCQswYGOVgJJQqAKqqLg3pQivpW8mjJS5dc5PMZ+X9JzDTvI8JHKMU2OkgVBELnDI2IXOZM2bmAYdjcWGoveu8rEzqjmUsasuDId9eCawHEjOI9YcOHhmxkshjU9ybFOqMEchRZEzyOQSe6Ba96Qx5GANE7Hgw3kOcy9o6qnNScQtsuqkmONmKAhCzIGJQN3gpuDY7XqfBcXMBKzU/DZDjuazJM06oasuCcIfEPYaIPWbw8h4tTUWKGDapcpKOmHUGAGZ96V6Jg8IkSBEFlH+XPiar3OLjUrVwoTITQxgoAsP2bg0Z/Huj2bn9vhVH8UTJL2QBo+Y9eQ896gWBAo10Y6cB4n3sVjxLE8uMt12HtO3z91U9lynOJpsPRmeoe6K0n5jkIBfp0dfvFZImvSAABQLDE1xKK44VC6DQrQ8JcclQPFs3t/wA/WvOLevibe12uvWLoA3Y9tVvbGLDKMLfZqao4qRymv5W9t9KZsVrzPQ7mvHqpj3Jy1ywScS/q79Hes7XprRQLz4mpRXVxavg+K5kYJ9YaH3bH4Wrz22pQS8zdGTsRsro3raWXMmPABOYwPHcoXaSDuq/gbH2HUfn+tWHwxMXYj4B04jrGB7vBQbegAsbFGjA9R9fFUFbNZdOc096wUFgA7BVVmCgBQ7KAzgAAd4nYUgQ2g3qYqQ6ajOZyZdh73pTYgnol7k35aBrsgRmzBc2YoApa9yBY6VwQmA1olOnZhzbhdhSmjLckzy51KOsbqxDMrRRsrMAFDsrIQz2UDMbmw3rnIs1JQn5kZP8ADgu882Iyx2OrLyo8rHuWLLlsxHLjsSCRkXwrvIspSi5z6YvB1/EdWnsTWIRJH5kkUEj6d94InfTa7uhY/GuchD1JQtCZApf7hwS2cFncpEXkFpGMMRZxcGzsUu4uqmxJ1UeAo5CHqQLRmR+/uHBEj5mZ2SJnYWZ2hjZ2GlgzMhLDQaE9B4UchD1LgtCZGF/w4JT4gm9whDZiw5aZWLsGcsuXKxLAEkgkkV3kmUpRJ57MF4fexApo4LsuIZr5iCTa5yrmNizAFgMxALsQCbDMa6IbQagJD5mK9txzqjNcadjroDcMSFVSWVQqsxUAswUAAm5AFDYbW1oM0RJiLEADnVplsRzyNgi+aRoh9Yvuig+uS3tJO9cbCY3EBLiTseIKPdh2aOpEOVJGKejJOMzMEWFZwbd9jlUOGyvr9YB9dDTQEG9QKa91oCFfcTSmytPFNxZVzZYoFzhg2WCIZg9g4ayd4NYXB3trTnIQ9Si9IzR/f3DgphLOpzZP5gcEGEFXESLcSER5LBWVVD+wbU24Qg4NpmpMOJORITo1/wCmujZ1Ji7PIJMivMNFkMSNKN9FkK513NrHS+lOGFDzIUZk5NEXWuOPvrSXUrmV1GosyugYEXDWZXBB2B1HQUshrxrCZY+LLvqKtd71puFES+SGBcwAbLh4RcBgwBtHqMyqbHqoPSkchD1J7pGa/wB+4cE40pL80hDLa3N5ac221hLlzgW032rvIsrWiTz6Yu3b5p705riyWcyBUWRhZpFjRZWGmjSKodthudbUCEytaLjp2Yc26XmnvTmgPa9kjW5ckrFGpvJl5huqg3bKuY31yi97UCCwGoCIk7MRGlrnVB2Dguxy5ZOaqoJToZRGglI0FjKFznQAanpRyLK1ou8+mLt2+ae9OaXHi2XLlCDJfIBGlkuGByDLZLhmBta+Y33rnIs1LvP5mpN/PYOCakIbIGjiYR25YaGNhHYADlgpaMd0aLbYUcizUgT8yK/Ocerhgh3JJJJJJuSdyfE06BRRHEuNTmrDgnCHxD2GiD128PIeLU1Fihg2qVJyjph1BgBmfLrXomDwiRIEQWUf5c+J86r3OLjUrVwoTITAxgoAn6SnFjeCraFPO5+JNZC3Hl8/E2UHcEiym3ZRnad5Kh9pX0RfEk/AAfvVx8MsBfEfqAHjXwCrrefRrGbSd39qhrWrNooQpfDeIxwsTK6ojC12Nhm6fvWf+IJQxobHMbVwNMtBB8wFfWBHuRXsJoCK9oI8iu8S4lHMw5Tq6qNSpuMx39+3xpHw9Jugte97aONBloAB8T3JdvzF97GNNRQntrTw8VDrRrPIoQrrs2/eceQPwJ+dZn4lhgshv0gkd2Hgr+wnm89uwKx40t4X8rH4EVn7DeWz0PbUbwVb2q29KP7DuIWTr0dYdFCEUIRQhFCEUIRQhEUhbEDDIURhCsrSSQyzLdy5VP5TIsQyJmLu2uawGmsKLHcHUC0MhZ8J0EPiCpKiHiMvIin5AjR8MkzycmXExh2BJQiKVWhjCgNmbObNvpq2Y8Q6VJbZks0nCtdZy6lPw+MQ80skXLgWFyyM5VicK2JnszG5jsYwugNt6cZGeQ4k6FHjyEBrobGjN2s5AEqHiMZMuHkmK4WN4cLBiJIikzZhLEX1kMqiK7KyBVDm9rnXRvl361J6Plh+zPacO9SsXjVWPFycpQuGMoQEtdjDhUdlkObX+dIq90DYiltjPuuJUaJIQBEhwwM61xzAHEhKxWLcYiUuqNKv0dg0BDZBLimEuLZRmuCUZbnNeygEkCmA4g1CtHQmuZcdl1pnH8ReNmSCOMsyYZYy7SKeZjcS8SLnRwVAgVjcDMCQb6U9GiOqW1VfZ8rCENsWmOJHVjTuTUk7xHEtljnkWHDCB2M+hxeJ5fLKy4h7qeWr3BUkDXe1NGrHbQpoLJmFX9p7wu9osaxhxM0Nkhg5yRozTkzCOYxm4hxEaIrSOUXuszAXbcCh1XAvKTCLIJEBuonsr6o4jxZYFxh9GvFhUMUGSKR4zJFGiKWmEmUIGuhjAuLC7XvSmxXtFAUiJIwIji5wqTtUrtJzsMksvLw4ESK3KZZS0gzIr2k5iiIlmIQBX2Fyb0vlIt29VRhKSfKcldNSCdOCVi4gkjoNQrsoPkCR+1TmmrQVnorAyI5o0EjcUzXU2ihCKEIoQihCs+B8HfEPYaIPWbw8h4t/ntaixQwbVMk5N0w6gwAzPvSvRMHhUiQIgso/y58T51XucXGpWqhQmwmhjBQBMcV4kkCZ3P8A1Xqx8B866xheaBNzMyyAy87s2rzviHE5JnLsxF9gCQAOgFWLIbWigWVjzUWM++47tC0HBmvCnsI+BNed2yCyfiV1jvAWwss3pRnvIlQe0q6IfNh8bH9jVx8MOoYrOo+IVbb7aiG7rHhwVOcO1gbb/v7fLWtZeCz/ACTqVXTh28P/AFtei8EGE5Q8fw1ZktIDYEHQ9bdPHQ/nSXBrsCnIMSJBJc1KwHCFhUrH1IJ1ubkC29tbW0oaGtySozokU1dipPJPl8R5+fkfhS7wTHJuQYG8K5eC7yTtStOzS95z4AD4n+1Zn4nf/ihsGkk7h6q7sFv+R7tQHefRWXGWtC/sA+JFUVjNvWhDptO4FW1qOuyb/eZCydejLEIoQihCKEIoQihCKEJ9ZlBchADIFEtmbvhYeQvXu2Tw660zyAxxzVgLReBDAAozvwpioj4KAhlETKrRpG6JPKiOkaCNFkVXGayALe4uN6RzVutSOmIv+oS5oInMhaM/zcvNRJZEhkyqEXPEjBSMqqthYEDUGgyra5pLbYjBtCATrSsSsckgmeMNKoUAlmydx3dCYgRGxUu2XMCBpppSubsrVIFqxgy6KVxx6+5Ilw0TFy0ZPMfmSJzZBA8lwTI8IbIzEgEj1SRqDXObNrmli14wbSgrrT+LZJM2ePVphiGZXdX56oqLIjKboQosANNTXOat1rotiLUYDjtTcMMKsXWHvmRJS7SyOxljjeNHJdiTZXbQm1zQJVtc0OtiKWkXQljl3zGIFi2HcnO+rYUWg0BtYakrsSb110uHOJJSIVqRIcMQw0YCiQkUXfvGxEjiR050giMglWXPys2RWLopNh4jQGuGVbrS22xFAoWglIfCwm4KSZWk5jRieUQly/MJ5WfLYv3rbX6UGVbrXRbMSmLRVL5ceYuIzcymYrzJDDzic3NEJbJnzd7UEX1tRzVtUk2vGLaUFdaCakqqOK5QuIoQihCKEKz4Hwd8Q9hog9Zv2Hi36fq1Fihg2qZJybph2GQzPl1r0TB4VIkCILKNh+58T51XOcXGpWqhQmwmhjBQBMcW4mkCZ3/8VG7HwHzpUNheaBNzMyyAy87s2rzniWPedy7nXoOijwFWLGBgoFlJiYfHfff/AEotLTC0PZue6snUG49h/uPzrFfE8vdisjDIih6x6HuWpsGPWG6EdBr2H18VM4rhuZGQNxqPaOnwuPfVbZE4JWYa530nA9unfRWFpS3LwC0ZjEdnuiyyNqLk2v4+79K9FIWKaakVKce1rhz7Ovh+1cHUluoMQ5dKjXv20B3vcnfaudiVQf7U7aoK2/5PDr/fy/SiuxcIpk7378kBB0e1uvvI01/y9FTqRdbod7x2ppmI2b86UAkEkYVWl4JhskYJ3bU/t+X61grdnBHmCG5Nw48Oxa6yZcwoALs3Y8E12gzFFVVY3NzYE6D2eZ/KnPh3kmRnRYrgKCgqQMT17B3pq2+UdCbDhtJqamgrl6+CovRJPs3/AAn5Vsefyv3W/kOKzPNJj7bvxPBHokn2b/hPyo5/K/db+Q4o5pMfbd+J4I9Ek+zf8J+VHP5X7rfyHFHNJj7bvxPBHokn2b/hPyo5/K/db+Q4o5pMfbd+J4I9Ek+zf8J+VHP5X7rfyHFHNJj7bvxPBHokn2b/AIT8qOfyv3W/kOKOaTH23fieCPRJPs3/AAn5Uc/lfut/IcUc0mPtu/E8EeiSfZv+E/Kjn8r91v5Dijmkx9t34ngj0ST7N/wn5Uc/lfut/IcUc0mPtu/E8EeiSfZv+E/Kjn8r91v5Dijmkx9t34ngj0ST7N/wn5Uc/lfut/IcUc0mPtu/E8EeiSfZv+E/Kjn8r91v5Dijmkx9t34ngj0ST7N/wn5Uc/lfut/IcUc0mPtu/E8EeiSfZv8AhPyo5/K/db+Q4o5pMfbd+J4I9Ek+zf8ACflRz+V+638hxRzSY+278TwR6JJ9m/4T8qOfyv3W/kOKOaTH23fieCPRJPs3/CflRz+V+638hxRzSY+278TwR6JJ9m/4T8qOfyv3W/kOKOaTH23fieCPRJPs3/CflRz+V+638hxRzSY+278TwTckTL6ykX2uCP1p2FHhRa8m4Gmo18E3EhRIf1tI6xRIp1NooQrPgfB2xD2GiD1m/YeLfp+rUWKGDapknJumHamjM+XX76/RMJhUjQIgso2H7+Z86rnOLjUrVQoTYbQ1goAmOLcTSBM7/wDivVj4D50pjC80CbmZlkBl53ZtXnPEse8zl3OvQdAPAVZMYGCgWUjzD4777/6UWlJhFCFIwGKMbhumxHiDv/nlUK0ZMTcu6Ec8xsIy4dSlSUyZaMImjT1LXxuCAQbgi4NeaPYYbjDeKEHFbtrg9oe01BVFxnhliZEGh1YDp4keVbGxrWa9rYEU4/tOvYdvj155q1LNLXGNDGGkato9+kGRYLDK8t+t0X8u/WjF7UPfYqgiBTAu3D/6TjJhsujzZv8Aotv/AN/3rlX1yCWWy13Aur1Dj5ohTDZe882bwCLb3d6gl9cAENbLXfmLq9Q4puNYNczy+VkX8+/XTe0USGiBjUu3DipfCuGZznYHIDpfQt4aeFUdrWsyA0woZ+fTs9fBWVnWaYrhEePk0bfTxWirCEjILWUTccytorKfYQepHTzBHtB8KCxwzC7VBmUAEsLHY3FvjRcdWlEVXUlU7MD7CDtvQWkZhFUotbc77VyiFxmABJNgBck6AAbk0AVNAhQ8DxjDzMUhnjlYKGPLYOApNgSVJA16U7El4sMXntIGWOC4HA5KdTKUkSvlUsQSACdAWOgvoBqT5DU0poqaLii8J4kmIQugYAOyHMLd5DZrWJBAOlwTqCNwacjQXQnXXUyrvXA6qMHxNJJJIlDh4sucMhUd4tlsTob5SfZY9aIkBzGNeaUOVCgOqaKbTK6ihCKEKNHO5kZDCwUAFZMylW0FxbNnBvfpbTenSxlwODsdVDXh3rlTVSaaXUiUkKSqliASFBAJIGgBOgvtrXWgEgE0QuoSQCRYkC43seouN6DSuCFDXjOHMpg58XOBy8suoe+UNYKTc6G+lO83i3OUum7rpguXhWiexmOiiAM0scYJsC7hATa9gWIubA6eVJhwnxDRjSeoVXSQM0xh+M4d1VknjIb1TnAzXcxgi51BcZQep2vS3S0ZpILThs2V8MVy8Nag9p94/wDy/wD5rU/CuUX/AK+azfxBnD/7eSo61qzin8E4cZ5RHewsSx8FFtvPUD303FfcbVSpSWMxFDO09S9IwmGWNAiCyjYf5ufOq1zi41K1sOG2G0NaKAKPxbiaQJnff6q9WPgPnSmQy80CamZlkBl53ZtXnXEce8zl3OvQdAPAVZMYGCgWUjx3x333/wBKLSkwihCKEIoQrPhPE+X3W1Q//j5+zyqgtmxxNjlYWDx/69dR37LizLT5ueTifR4ei0qOCAQbg7EVhnMLCWPBBBWta4PAc01BVfjODxvqO6fEbe8VdSdux4Ao75gNefYeNVWTNkQYxqPlOzLtH9Ktk4DINmU/EftV5C+I5Zw+drm7uPkql9hxwflcDvHkUJwKTqVHvJ/auRPiSVb9LXE9VPNDLDmD9RaO0nyVhhOCourd8+e3w+dVE38QRoooz5Bsz38ArOWsaDCNX/MduW7irOs+TntVxRcNJXVkuKcF5EYw+AiYPiFWNmMkgRIIgc15CG5bFWKLYXu97HLVnCmeVdykdwo3EYCpJ2YV1n1TZbTALOYjCSiPDYaWBlSDEYsn/wCmkxcQH/AoUKM6ZZ2AbT/b8Rap7XsvPitdi5rf3Bh29RwxG1IocAtBwOIR4kPyWCLh4IkMeGaJS88sjyty7fywMsea/q6X3qFMOL4N29jeJNXVNGgACunTTXoS24FVmE4fK0mZvSgVnx87nIVYFByYFQlLMXicEFb3y6bG0h8VgbT5cWsaMcMTU1x0EcUkA+KvOKtifoyMMJWxDphll5YPMu7RiYjJaxAz66W8qhwRC54SKXQXUrlhWmfYlGt1VnEsTJJiBNlxa4UzRDuRzK+WGKR7iJVzhXldUJK2IT2GpMFrGQrlWl9DmRTEgZ5YAVzXDia6FAWHFZWTEpiTIcPfDpHztZ5ryEtNG/LQo5KWcCyhbG2hevQagwi2l75ibv0jDIipqMcMyk0OlTokxfpAzjENJh5izSjOIXwwwwYxhfUlZpSVAUFhbpbVkmAYWF0BwpTCodez1ig14LuNVEwxxOHw0sQjxJlOBgSEJG5UTOsjTSZgMisJJRe5DdzY048QosVr7zaX3E1IyFABrIIGGhGIFNin4XhUsmKyvz1ibETM7AvHmjw+Hiw8Ss4INnYu417wUnzpl8djIVW0JDRTI0LnFxw2CnUu0xVKZMZGoYelLy4ZWgR4cROHaSWcohyMMjrHylvMWtcEAWuZdIDiR8uJF4gtFKAa64E1Py0ScVruNQzxcPiEQklmh9FNgTnk5ckfMBO5zANe/ib1VwHQ4ky69QNde6hUGicNQ1Z6TB44DEJLJiLRHMJYgzF5MUsedo0DBmihvMMqm4DC3eUEThElqsLA3HQaYBtczoLsM9WopFHYpGFXELkWQYj0RpmLskeKLOESPIBEZDPCjMZQSSykxg2sdVPMI1Lbt+gpi3CpNcaXTTDbiuY6clI4XisRh3fmRYsqIJvR1yySm8s8jRRSEZu+Ejj1Y90PYkdURWQorRdc2t4XshkACRsqTlnTBdBIUGfhuLkCxvzc0T4OJsyztnUNEJJlcOISpJkLXWQ2BuRpZ5saAz520xDj+3PGgyvVGFMR1LlCU5NBjJAxUYpZLSQTuS4Vy+JSOKSNTp3Ys0hkQBQOvggOgNpW7TBzRhhRpJB6zhQ4oxKnYmCTD4y6jF+jCeDPbnTklcPOzMB3mKs7wqcotdNaaa9sWBjdvlrv9W5uA2ZAE440Ssik4HDTTyzSzpiljCYmRY80seYtKUiSyMCSI8OGyj7UH62vXvZCa1kMtrVorgdFScdpzOpcAJxKv+D8CRocM+Jjz4hYcOHd7ls0YzgEnXRyT5ka1BjTTg97YZo2rqU24eCW1uAqu9pjrH7G/atH8Kg3Yp//AD5rO/EBF6GOvyVJWsWcVjwHiXo8wci6kFWA3sbajzuBTcVl9tFLkpnm8W+csithiO1WHC3Vix6KFIN/MkWFQxLvJor59qS4bUGp1UWJx2MkxEhZrsx2A1AHgB4VLJhwGVcQBrOCz8WJFmolaVOoaE7DweZvqhf+x/YXNVca35KHgHXuoeZoO9S4VjzUT9tOs8KlSF7Pv1dfgTUB3xTB0Q3bwOKlj4fi6Xjd/SG4A/R1PxHzpTPiiAfqY4bjwXHWBGH0vB3jioz8HmB9S/mGH7kVNb8QSDhUvp1tPkCorrHm2mgbXqI8yFAq5VWihCk4TGvGe6dOoOoPuqDO2dLzY/ytx1jAjt44KXKzsaWP+M4ajl76lcYfj6H11K+Y1HzrLzHwzHYawHg9eB4eCv4NvQnCkVpHViOPipi8UhP/ACD36frVY+x55pxhnsofAqwbaco4YRB24eKH4pCP+Qe7X9KIdkT7sBCPbQeJXHWlKNxMQdmPgmfpuHxb4VL/AE7PHEhu9R+mpQaTuR9Nxfe+Fc/Tk7/Hf6LvTcrrO5H03F974Ufpyd/jv9EdNyus7kfTkX3vhR+nJ3+O/wBEdNyus7kfTkX3vhR+nJ3+O/0XOm5TWdyPpyL73wo/Tk7/AB3+iOm5XbuR9ORfe+FH6cnf47/Rd6bldZ3I+nIvvfCj9OTv8d/ojpuV1ncj6ci+98KP05O/x3+iOm5XWdyPpyL73wo/Tk7/AB3+i503K7dyPpyL73wo/Tk7/Hf6I6bldu5H05F974Ufpyd/jv8ARd6bldZ3I+nIvvfCj9OTv8d/ojpuV1ncj6ci+98KP05O/wAd/ojpuV1ncj6ci+98KP05O/x3+iOm5XWdyPpyL73wo/Tk7/Hf6I6bldZ3I+nIvvfCj9OTv8d/ojpuV1ncj6ci+98KP05O/wAd/ojpuV1ncj6ci+98KP05O/x3+iOm5XWdyPpyL73wo/Tk7/Hf6I6bldZ3I+nIvvfCj9OTv8d/oudNyu3cj6ci+98KP05O/wAd/ou9Nyus7kiTjsQGgYnwtb9aXD+GptzqOLQOuvkkPt2WA+UEnqoqLGYppGLN7h0A8K2MjJQ5SCITO06zrWZm5p8zEMR/9BMVLUZdArhIAqV0CuAVzgOBk96XT7o3956eysraHxGGkslcf5HLsGnrOGwrQyViF3zR8NmntPkN6u4YVQWVQB5Vk48xFjuvRXEnb7wWihQYcJt2GABsS6ZTiKEIoQihCw9eurzdFCEUIRQhInlCKWbZQSfYKEprS4hozKrouNK6hoxcEka3GxtsRTcq50a9eaW0OG1WsezGwrtH1qMaDIp3B44lrPYX9X3bj96kxGBoqFEjS10VYpcs6ruf891R3RWNFSU3ClY0UkMacM/ZS0cHY3pTXBwqCm4kJ8N114oV2uptFCEUIRQhFCEUIRQhFCEUIRQhFCEUIRQhFCEUIRQhFCEUIRQhFCEUIXJGsCbE2BNhqT5AdTXCaCqU1t5wbrWX4J28MeIMk0QEHqgf8ikG1wNy2972HdIuDvRWkx85BMNrqadh61rZKRhSxDqVdr4L1nh2PinjEsLh0bYj9CNwfI1ho0CJBdciChVwCCKhQMb2jgjJF81gDdSttTlABJFzfTS9utPQ5KI4VyUhku91NFV3hfH45nCWCsUDAZg3hdTbZxcXWiNJuhtLhiBs7+raiJAcxt7bRW1Q0wihCKELD166vN0UIXaEKr4h2gw0NxJMtx9Ve83wW5Hvpt0ZjcypcKSjxfpae3DxWa7R9sInQRxBjmsSxFhl8Bre9wPgaSIzXZKylbNiQn330SMPxKRYkUKb7XaygEnRbt4XtprepHOYbGipqpwli5xJUVuJZDmmBJLoqEBwy6kswzqFK6BdSL30FrmosScv/KR8ulPtlw3FuauOH8YGIaRTFJIwP8oKBmbUgqwzL4k7/prDe1o+lPMqKk5lW/DocaJA0uFOHgsQeZbOzfVy2N/M3Hvp2WBvqutcs5DHOuHn3K2qeswihCKEIoQihCKEIoQihCKEJ3kNa9vH26b/AA39mu1JvBOcm6lT7959WOSapSbRQhFCEUIRQhdoQuUIRQhFCEUIRQhW/Z/B5m5h2X1f+3j7qzPxHaBhwxLsOLs+rV2+HWr6xJPlH8u7IZdevs95KD207BxY3+ZGRFP1a11cdc6jr94a+N+mekLVfL/I/FveOrgtM+HeVdwvAjhSvCzHJMpvKduYFIDDoo11HQAf0lmkxYnP6Pbm05bPfvHCTCggC83GmfFZThkY9DzLbnRYvS/g4TIfZmVveKnvJEeh+kt8K+Ssi83ntdiKV3HHeFaPiALop70LznMosSbIqn252uBTTYbiL1MCAO/gu3heJdpu1/E17l6ecfGHEbSIJCB3Mwza+AveqAScdzDEbDcWjTQ0VJyjQaVxUmoqWuUIWBxWJCAXBJJsALam1+pAHvNesRYzYeawUrJRJkm5TDOqgcJ4ocSs2TKhjy5VJzO2Y2uAbD9RrTESZOBZkQreFYzB/wAhJOzBcxXChjI8jtKoF+8HsW2ucgAV7f028ajPiOdmVZwZWDC+ho81hMZwkYWSSFzGzJqrrlsynYgsTbwIsSCCOlyy6qkBUfEWuMy38dz3dSTa5PUk9NdaW0kYJJVx2dx6tMpkZtVIUMxKiVmu2UHRcwN/bmFKXFpsRDe6kZlYG99R7NtqEKR/phioYsW8MzqMql4m3JAa2Q2uSwtp1IHsuLhWnPaf09ndRljRysQ1zFNO+wI0LG+ngB4VPgMLW4iiztrurEbjhTz/AKRT6qEUIRQhFCFzOoIDMq3/AKjakucGipTsGC+K4NaE9xaAwxhhZiSAVJy20uT1vYa2GtR+c7Fb9DHD5+vDwUGTHxq6RNIOa1wyZSuRrBguYkhrqykEH4XArsKPeNHJqcszkYd9hJpnxUmpKqEE1wkAVKWxjnuusBJ2YlVnGuPYhLQ4eEs+l3YGyWNl3AGdSRbe6sRYi1QIkyypulaeUsaPdbywIOgbBka7MR1YFLwmNIiVZlJxJZbspHLAJFwVuCDa/TwNxtUYTby8YnPs7VeOsCWEs+rQBdccKl1Wivyk6MhQEDMU0qwq5XnKKEIoQkzShVLMbAAk+wC59ugNJe4NFSnYMJ0V4Y3SmuzvZjF4gemKyKjNfIWYs6ZbixzCNSPVtl0tuaruWcHVqtTzGCYYYW4DfvTPDMdnizzGOJgzKwLjICnrWkvkYXtsTvrsTUlkzocquPZDhjCNdh4/0pMGJR75GVrEg2INiNwbbGpLXB2IVTEhPhm68UKcrqbRQhOYeEuyqN2IH9645waKlOQ4ZiPDBmVs0gVAFUWA/wAv7a8/t4gzAdpIx8B4LdykJsKHcbkEqq2UlHzL7jNVcU+5waKlRuIYGOaNo5VzK24/ceBpqHEfCfebmE6yIWG81ebcQ/0/xCMyQWdHIsxYAAA3s3UXsNdRV9DtOE9t5+BCmc5hkavehZPiscauscZYuFHPzgAicFhIot9UH/3WzsmJEfAuuAAr8tP9dBKop3/mLyaq57M8YXCTCTLnXKV0tmF7ai+l9Lew1YR4RiMugqDDdQ1IXpvZni7YqN5SmVeYQg+6FXfzuT/grzf4hlYcvN3WaQCeup8VaS0QvbU61b1QqQvO+MYLnQvHsSO6fBhtXrURgcMVgZOYMCKHaNPUoX+j+D5k+KeZVDKixgKMtrsWe3j6sZv8qgxIhPyrWtGlaqbsHNI7F+ItyiScohUNY62uCEv55TTVE5eXneC4bhcbiZViORIGjhiFs38pnMUc52znnsryA6FcQSCCtDmnSuVqpfFuFYf0OXLF60TMq3BKNyIcTH3tjJGZHW6+vFIL3K3ou6Fyq8z4c5D5LXD2Vh4g6g69QbEV1dXo3C+DyRqommR1AbukOzHMQRmzSZTl2Ay28QaACklwVx2aweBErM78t2BWOUMUYyeUieoQNgLb6bUvk30qAk3xWhUzhGHYc0TBg6sBHK5IBiIF15am2YH62XXxqSHRXBrh2hVk7za45jjjo0lSqkrOIJoXQK5JmDGRuSEdWK2vlN7X22pIcDkU4+DEYA5zSAdacmTMpW5W4IuNxcbjzFdIqEhpoQaVWQ4vx7lzTAYHLaLK+R2ILANaVmy3y2INvzveqt7SHUK2UvEY+EHQ8AUnG43myIkCSKGjQoJMpFsrBjGzX0AOpGVjvtpXE8keixowWN1aXQsFzSFMgJDFRvY2FmGt9CKFwiuC1fC8cJUv9YGzAEGzeF1JB+O1jperCDEvjasrPynN34fScuCmKbEHwIIPUEG4Iv1BAP8AauxoQitun2UWdPvko4itFRkRracwoHF1mZjLzb5sqtYBLD6t8ulr6X8TrvVJMy8WGak4FelWNa9nzjeThsIc3GhxO0jX1KqwM5j1IXU6C9zlsLhmABW920BuLD3x6tbkrq5Fj1EQXQCaaajQaHCuRxBFCp+B4iSQhUsdhbVj7QBqfZU+XtEgBrxXasla/wAHscXx5d4bpukUbXUDXAHUa010VqR0q5BqvOiCDQrlC4mMZh1dbNmt5dQQQQR1BBPgfAim4kHlMK0U2RmhLvJIrVMwY/GLGMPBODDlMbAC0yrYBSoLWV1X6wJHkNqhxJd8PMYbMlpIM1Di/Sd6zPEQsFzYlEQX7pRmz6rE/KcAySOGzMmqGPK1zTKkK/4ph/R0E+GxKTF8pkGYSCUsAiz2zgm7FFsWOhuLWZSDA1CS5jXgtcKjapPCjIYw0rKxbvLlUrZGAKhg2ubU79Lb71YQHuc2pWYtGDCgxbsPVipi7i+3WnjkoDaVFVpuEYGINzI3L2FraaE9enS/51XTEaIGEFu7StJIycu1/KQn3vKqtZBWTtmVjPicsB8oA7M1ewnACi4tOWIwMaYjjS8aDbT33LkY1wSGF6h2ZBPPbrv217sEuIfkWe7dcSkw2BkkiJDDKpYC7KrMFLKP6tdPMj2U7BgQ4lpua8YAk00EjGh2a1wkiHgvIe1XDvRMYUVi0MiLJAxN7oQL3PU7Mfb51q7OmyXBzs8iosRgpRJjXMdPf+9aSqgnDNelf6Z4wBZMOfWvzF8wQqt8CF/FWF+LpV19kwMqXTspUjfU7lOkYgILVt6xqnrD166vN1m+LzS4KY4mC+WSwkUGxzDYqbHKT7CNNQekONCJdVoWjsuaDofJuOLfD0VxxHti0uBfICjOTE5ldWkAZbsY441BckXUNpZiNNq4Zd7fqG1WAiMORWawzzYLmRxwZ8rKVcd0Z1eKSKQA6m+QdLHMQadi8iYbXCuS4y+HGqRgnxWMBAzxxrHdBF3VVFDqgJ9YoEkZAf6bDWwFNQXsvULcEt4cBgcVH4N2PcusvLMeXVTJ3QRbwbvb6ghT1qXEgQr1QdyiPnRDHzke+9ei4LEcpFVQoYCzOqDMxO93kvcHyVetrXprkG1qoMS1qCjB799SiwRqn+2qobWuPWt4Z2Ja3le1PnHNVkSbiv00GxZrifbOKIkCN2ILDUZVupIIud9QRt0qMZluQU+FY0U4vIHeqCftripDaGMKLjYZj7NdKTykR+QU5llS7Pqqev0UKaDFYpizM5UsbDVgtzoNNBuB/hpQl3u+oqYzkoQowAdS0XZTDrhS/MfVyoIJBta+vdJtvrf9tZUOXujBVlojlmi7mFr1YEAg3B1BGxHlXFQkEGhVdxrBh1OYXFtrX2B6ZWudyNCfWXUsLQ5lhreV/ZEdt0wtOfWsTLg3zJhhEZiWvEFK5yRoY3dWJXKuaxN7hVOUDWoiulbYXibxR5L8pAsi3jQBo5FuYlbNc2JGQGyHM1rm3dQ+9hdp6JTaaVIfERYeSJojKA0K51lNzpcugzAEMgGbUqCBZQfqrgve3F2aZmoEOOwsOXgda1EMoZQym4IuCNiPEHqPOrVrg4VCx0WE6E8sdmESoSrKLXKka7agimplpdCcBnRTrGjsgT8GI91GhwqdnDXsTvCuyU4QzOFHduq7tuOuwO+gv7utTJsDH3nrefEk8ZmXMKVcag1JGFQK4DTt7FY9n8cscnfUENYEkaixuPM2P+bVYx5cfW0LH2dakQ0gRnEjRU5HVjr7lZ9o+F5hzk1IHfNgARoAVG/6+3a6JeNT5TknLUkb45VgxGe3b1hZip6ziKEJEsKtuL+fX3GuhxGSUHEZKO/DkaRZX7zqLK5tnG+z2uQLmwNwL3temokFj9FDsU+DaUaHhmNqg4zgQeeOQCEoFYSh07zm3cPdFi+65z0a+U1EMu8GgVoy1oJbV1QdWe71otBCoCljZidWvY6/etYqfMabU8xpbgPfkfFVcaMIlXnHv4Ob3hM1JVetJ2XjtGzeLfkAPmar514bicgKrRWMz/E46z5K0JrzuJORn3quNDorh1LRhgCUBpV/IP5Kzy/VeI99aZeKvomknBFwQRUKz3c2iPEarXEChpWmnHPNLf8AMMFE4rglxMEsN9HRkv4MRofaDY+6m5mbuzrY4bQCh6xr7cl1rfkovJeOw+l8MEyjLiMDKFkViBYOFuNwAtyRb/7ftrRNNyPd0OFQmDiFl4W8L6eR2/vWqglxaCa1URwat3/pvhmkxIdnZOUpZVt/uKQUYHyBI99qo/iiNck7t2t40r/qc6+9qXKNbymBXqlecKzWHr11ebpnGYcSIVPXY+BGxrhroT0CKYTw73Rd7XcOSdYWw6CNxZmZmtckDw6Ai4Kj9aZlY8UOIcMFo48SWawOvCue2ij8OwLJIZZ5TiGYAFXF07vq+vfMB0FgBc6U9EDXtDaUCr3WpdNWCp2qZh41jJMSJHm3yKF22FxrYX0Gw6CuBopRQIk7GiZu3YJVKUVWPBOGiZmBYgKASANSCfHYf3piPGMMCgVjZ8kJpxqaUorfiPA4BC9v5Zym0jMRY7gkk2A/aofOYlc1eiy5YDBvfX0Xj8nDpGUyzCLQ2ylrvocrOuwY63uNDe42NPS8AMfVxzUiI/5aN0J/ifDBEVKr/LkGaPMQdBpYhe7cG4sb7+dWkAhwocxmocYub9ORXcDxNohYBSBqoI7qnyX1d9dupp10IOUcPcM056e8gKuQFYi7BRcWFhqNSu1xr4gXpiI6HDxBxGiqehtc/CmGtS+z2PcWjlIudj96/wC/h41XQHUeRXA5Jm1JQGGIjBiM+r0WgZbi36aEeYPQ+dS3CooVQQ3uY4ObmFmuN4MgFlJVlIaMqCMkiDulbZrLa3dVblQQTaM1WRGFpothLx2xoYePZVXhcM0+SNlZD31lMwDZ5ie+VAtcgkgOwN82uu7TnUUgCq1MnZxTEFd5GItlINrMosjgD64yjvWvpr5ovlLuhV/CcUYZDBJ3bnTe2axJ7xv3WAJUs5PccW0sJkvFummgqptKT5Zl5v1DvGrgtBVgsutH2d4p/wAT209Rm1A0Otvfrt+pqvmYV03xlpWjsudvjkXnEZbRq6x4dSb7ScLsTMgOUnv6W71yLgeF+tragi96dlo1flPYo9qyN08swYaePFO9nuJ3tG5Fx6jNcgb9Pb7P0s1MQbpvDJTLMnuWbyT/AKhltHEd4x1qHx7hfLPMQHITrcWs1zsP6T00t4aWp6XjXhdOar7TkeSPKs+k57DwPvQqepSqEUIVF2n44+GMYEekgJDtfLobWFtzfzqLGjlhugK3kbObHZyjzhsVZw/tmT/uIvT1TY6+RJvTTZp1cQpkSx4RHyEg7cVro3DAEbEAj31Oaaiqz72Fji05g0Sq6kgVVpwzipQLHYZSwuetiReq60JbloESmd0+CtZG0HwS2ERheGOwnFaWvM1sl3NparMT4ElzcA1rnozqm7nz3lU47hCWDRxqGUjSykEdQQwtfz0PnS5S0HlxbHebp3g7CMvBdczUpnDlAjXKuW+pFsve66dNaiTpfyxDjWmAxrhoxSm5LA8f/wBPppcVJJC8awyMJCrFgc+pa4CkHUswP3z4A1obOtyXgQW8q0l4wwpSmg4nPR2KNEguccMlPwX+ncdgZpWJ2tGABb2sCTTsb4uiZQoY/wC3okCSbpK0PCezeHw7Z41bMLgFnLWDb6E2/KqWdtubnIfJxSLuoCmXen4cuxhq3NW1VCeWHr11ebrtCFZcP4JJKA11VGFwSb3B6gD+1MPmGNwzVjL2XGigOOAOvh/SusNwGFLZrufPb4D971GdMvOWCt4NkwGYu+Y7ct3FSuJcOWSMoAARqlhYA+7odqbhxS11SpE3JtjQbgFKZdaxTKQSCLEGxHmKtAa4rIEEGhzVhwTiAiZg2iutiRuPAi3+a0xHhX24Zqws6bEvE+b6Tmsbx6Jnd0u8jk54C5zlkH+5Hdybnay2O/QVDdBMMiI80GWwaitFAm4cwCIeNN6j8Jkw5N58x7qgKrWzEXGpCsdLAG1tbVPiQXGGLor5eCQyK2+alPcV4jDZlhgABXuglmyyDQnvNcki3rAWsO7reuwuUc2/eqfL3/a6+4Ddos7LxBE9fuNpdWuG/DYkH2gVCfHivwJT7YTG4gKNNxpiO4jEG9ie4p8PEm2uxGvs1QGHSl1ScO87MCSFF9l020sXN2IHtPWnGUhuqcaJt7S9pGtb/geMaWLM9rg5TY3BsBr7damQ33xWlFlZ+XbAi3WnRVSMbhw6kEXHUb3Hs+t/1+sLqdGNIjQ7wqM0uzprkYlD9Jz4rNT4YR2Q2AsATewyi2VwbIpK5lFlBJV1YsNTVa5tVqwaLWcDxrTLlbV09YX3X6rj7psNdvPamQnMFW9ocdBFIkki5irKrFd0Vtmv61gVWzKPIMbkU406EhymYCFxDHIzh45gWhbMS5TS6yX1zAm17kkWvY3FWMvEqLpWatSUuO5VuRz6/VSFYg3G9SCARQqqa4tIc3MLYcHx4nTK4UuAQc+o1GXReuhPmRcXqsiwzDdTRoWtk5ps1CxzyI96Cs/xfAGF7rfI2qN+2vh+YqbCiCI2hVDOSzpSKHMyrUHVs95q+4VjVxCFXy57WObW4IsLDx1P+bQosMwnYdiv5WZZNwsRjk4e9B9Fm+KYTlSFQSRupO+U7fuPdVhCiX21WanZbm8UsGWY6lEpxRFuezGGhxGBRZESRCXOV1DD12sbHxGoPgarpj/kK1tnNLJdoO3vKz/azgPD8JEZEw8Ubm9mA2sDqBsNba02xtSpb3UC88TtfJK/8uIMTuGJDFr6kZbkDw7vwp8TJbQUVQ6yRELnudiSTgK8FM4z2WxuNiTE4dSwUFJIM1mVh9YBrBgRbwI8KaivLzUqfJy7YDLoz0nWqfg3BuJI4RMNOGuL3BCjXW4YW996Q1xaahPxITIouvFV7Nw+UtGpa2YaPbbOujW8risLaEsZaYdDOWY6jiOClS0ZsWHeG0doNFIqEn0UIXaELlCEUIRQhFCFh69dXm6YxURey3sp9fxI/pHhfqfC/jcJcCcE7DcG1dp0cexa3srjLqYj9XVf+vUe4/rUOZh0N4K9siaL2mE44jEdWn3tV8ReoiulyM6V1CznajA2IlXrow8+h/b4VMlon7Cs/a8rQ8s3TgeKz9TFRqHxaK8bMASyBmTKbNcKdAel9vfSXuIaaalMkHlsw0aCaFYt8aQeWilyxFgOpvYdC1yeg8ag8tEzvFa3kmUpRW/Du0rQwmOOFBNGWkvygXzBtc0h9VVsb3G1/A3XFL3fMcqDqSWBraga1TY3mYqYyMjysVUAjvi2p9e1lAJOlx19yWw30wSYseFD+twCsMJ2anbflxA7/Xb8rD8zTolzpKrotsQm4MBPcPfYrbC9loF9fNIfvt3fwrYfG9PiE0Y0VbFtSO/AGnUrmCBUUKiqqjYKAB8BS1Xue5xq41KXQkqu4thHKExScsj12C3bl2bMAQM2mZjYWuGN9ALQ48GlXBaCzZ6/SC/PQfJVXGcPjMLbCsljPHHZu6z3XVwrpawzAG7Xa431FRbtTgFcueGirjQK4hwF48koXvLZwvqknc7A7km+9z8VwpJxN55p4qrmraY0XYIqdejie7tUjB4RIlyxqFHl+pO5NWLWhooFn4saJFNXmqepSaT2ExJjcOu4pESGHtoVIlph0CIHt/salrHmjxULKDmcjYm2VtLED3fnbrVaL0J+K1LuSnIBDTUEbjo7Vj45CDcEg1ZuaHChWShxXwnXmGhUjHY5pcpfVlFr+I6f550iHCEOtCn5qbdMXS4YjVpUUqpBDglSLEA2Pxsf0pw10JiG4NdUivcrHgPEDhY+XE5ygWUSLew3sHTXck6qRqbDWmIsMvNT3evFXMG04bRQ1Hf4cFUdomxWJPfCOtjbLIJLdbCIrGxJt4EbX0pHJtaMSd1O+pUxk02KflIPb5YFYt+DS4cszOyP3iwkUgHZmNnGouyDQd5mNhYE09DEM4US3ucvZ/8ATh1XBqc4Kk3DaDVhqpA0VhsR5aaWqJHbR9KJ+A4FtVZcb7QwQxyEypnVSQuYXJsbADrTNE8CFgf9PuJzcmM4lgWlGYm1rEnuk2HVbX91Qbcs50xAEZv1N72+me9VUpOQ4E26CMGk/wDr1y3LcVhlpFyhCKEIoQihCKEIoQsPXrq83SZA31SB7Rf9CKQ8O/aR2ivmE9BMEV5UE9RA8WuSsLjWidXI2O66+0Ebi/vpp5dS68Yaxwz8VNgNhh4iS7sR+11AT1O+k9t06gVtpuLRKoYtuAQPra+XSoTYbnZBaGLNwYQq9w8T3KnxfaNjpGuXzOp+FSWSv+xVRHtknCE2m08FTT4hnN3YsfOpTWNbkFTxY8SKavNU1Sk0ihdVBL2XQzc1XK6htrkMDfS5tbyINNCAwGqtm2xFDaEAnWrGHhEKksUDMb3ZgLm++gAAHkABTooMlDizsaJm7cpwFtBQoqKFxFCEUIRQhdBtQccEppLSCMwhmJtck2Fhck2G+UFiSF8thSGQ2tyT0eZixzV54LlLUdFCEUIRQhKjcg3Bsa45ocKFOQor4TrzDQrhNdAokEkmpXKFxFCEUIUXiWEWVCjKGU7g9bbDXb20iI28KKRLxTCffBoffuih4DhskTry5plQHVM5MRF9uW1xqdh0G5N6jtl8VZvtQmGaZ6Pewbzkr+PFkCwVV847xN8Yitx5G48qfMMHTvx8VDZaMVudD3eFFB4hgIplKu82tzupvpbKSoTu9dQxrgh3TUAe96k9KVbiCDvHknQLCw2p1VBxxK0HB+KXtHIddlJ6+R8/1rF21Yphkx4A+XMjVtGzw6lqLLtQPAgxjjoOvYdvj1q5rLK/XKEIoQihCKEIoQs5LwGVTZmiU+BkAP516qZqGMysY2xpt2IbX31JcfZudhdchHiHBHxFd5zDK4bImQaEDelfwviPBfxUc4Yk9EzGzej+F8R4J+KjnDEdEzGzej+F8R4L+KjnDF3omY2b0fwviPBfxUc4YudFTGzej+F8R4L+KjnDEdFTGzej+F8R4L+KjnDF3oqY2b1DfhhDFDLAGBsVMq3B8CPGliJUVodyT0ZGyqN6kv2dmBAPLBIJALgXAIBPxZfiKRzliV0TMbN6SvAJTaxjN9u+PG36kUc5YjomY2b1xuAyjrHoub1we6Da+nS9HOWI6JmNm9H0FLa+aIa21kA1va2vW+lqOcsR0TMbN6V/D8vjH+Mf51FHOWI6JmNm9c/h+a9rx/jHjbfbe49xo5yxHRMxs3pwdmcQRcBLb3zi1vGjnLEdEzGzeuR9m52FwF/Fb9RXBMwyumyJkHGm9K/hfEeC/irvOGJPRUxs3o/hfEeC/io5wxd6JmNm9H8L4jwX8VHOGLnRUxs3o/hfEeC/io5wxHRUxs3o/hfEeC/io5wxd6KmNm9H8L4jwX8VHOGI6JmNm9ViwoX5YxOFMmbJkE6Zs97Zct75r6W8adLiBeumnUk9GR8sN6sH7OzA2JjBtexcDS4F/iQKa5yxK6JmNm9JXgEpAIMdmF17419lHOWI6JmNm9cbgMo6x7A+vfRjZTpvc6Uc5YjomY2b0fQUtgc0Vja15AN7W39o+Io5yxHRMxs3pR7Py+MfX646Xv8AofhRzliOiZjZvR/D817XjvYH1xsSQNdtwfgaOcsR0TMbN6bxPBXjsZHhQHbNIq39l96S6bhNzKbfZ0Vn1lo6zROQdnpnGZDGynqrgj4iutmobhUFKbZcdwq2hHWrjAYDFJZXVWXxzDMPn76z1o2PLxyXwTdd1fKeHZuV5JPnIVGRQHN68Rx7d6s/Qn8B8aouhZrUN6t+Waj0J/L40dCzWob0cq1HoT+Xxo6FmtQ3o5VqPQn8vjR0LNahvRyrUehP5fGjoWa1DejlWrJdp+yOJlxks8aQSJIgUCVmBU5FW9gNwVJBB61pYkAueXUCtZK04UKXbCcXAg1w04krQ9h+DyYXDcqbLmzs3dNwAbaXsPC/vp6DDLG0Kr7TmmTMflGVpQDFTE4XICT6Q5uDproW5hJHe2zSCw6BFHQGnVXpTYCW/dxBUXuRlv7gWJIHxoQpOCw7pfPIZCbbgC1idgNOv5UIUmhCKEIoQvPW7P4wNjssKnnXET83Lo8yk+q4IGW7EEa5bagkGfy7CGY5Z4bFH5N3zbVsOJopbvQNLZQQQL9SMv5g2+QqApChlYgS3okpJBvcE3BsGBud9R7fHQ2ELsCI2QHCyAkFD63dV2Oa5JBtdib777aXF1O4XCxsz3w7Ldm71yM3fXvG5G+jW8j1FC4otlOa+DYfW3a5P8wrYgaGypoPVMltxQhWWGwcbpd4spO4N763Y672OdrjzINCE12iwLyYVo4R3u5lANtFZdLnyBqPMsc+GWtzUyQishR2viZY7dCq+znB50M3NzJnRQpzA2OtyArG3SmZWE9jiXbFKtCZgxWNbD0E6OICtfQJ7i2JOzXuoN2JupAvYAXOg8vdOVSlzYCRtp2U3F7DTRgwsL6HSx6EHUdaEJLYGcn/AOSQNNo1vfrvfy/PahCcGEl0/nk2Av3BroPA77/HyFhCbHD5gthiWBuSGyg6HUixNjraxO2vjoITkWBkDKTOxy2vp63eJNxe1yDbQdBbahCwS9jsf6RGxTCiNMSjlwzcwxpMJALZPWsNr2vTkK5DLiHE3tG0imvLsU/nv+Dk7grSldnVTPt7FueIIpks2HaS6gZx7W7pPQdfffoKbUBQisVv/hynXKLg+NupNh3ifPvbm9CE7CsbPrhpAbZSxzWtnDbk3JzWa++hoQmpQigquEkN9NmCketc2O2mx6sfE0IVn9Fw3B5YuLWNzcW2sb6W6eFhbYUISpOGQkWKAge3oWNt9u+2nnQhV/GIJOfG6RF1yFSVKB17wN15mmo/9jrHiNdfBAr72qLGDxEDmtrhsqN6OE4OUQSAryXeQsBcGw7upy6XNje3U7dKXBaQDUUSpZrg03hSpOH9KTFgZge9iWI8MgGlgNSDcnQm99zTqkKTgcOyKQ0hc3JuRtfW250oQpNCEUIRQhFCF//Z");
  delay(4000); // รอ 4 วินาที
}



































//void Line_Notify(String message) {
//  axTLS::WiFiClientSecure client; 
//
//  if (!client.connect("notify-api.line.me", 443)) {
//    Serial.println("connection failed");
//    return;
//  }
//
//  String req = "";
//  req += "POST /api/notify HTTP/1.1\r\n";
//  req += "Host: notify-api.line.me\r\n";
//  req += "Authorization: Bearer " + String(LINE_TOKEN) + "\r\n";
//  req += "Cache-Control: no-cache\r\n";
//  req += "User-Agent: ESP8266\r\n";
//  req += "Connection: close\r\n";
//  req += "Content-Type: application/x-www-form-urlencoded\r\n";
//  req += "Content-Length: " + String(String("message=" + message).length()) + "\r\n";
//  req += "\r\n";
//  req += "message=" + message;
//  // Serial.println(req);
//  client.print(req);
//
//  delay(20);
//
//  // Serial.println("-------------");
//  while (client.connected()) {
//    String line = client.readStringUntil('\n');
//    if (line == "\r") {
//      break;
//    }
//    //Serial.println(line);
//  }
//  // Serial.println("-------------");
//}
